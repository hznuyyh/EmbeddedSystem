# Keil uVision project Test.uvproj, settings and files
target Test (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\BaseDrive;..\ExternalDrive\Lcd;..\ExternalDrive\Fat_spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_it.c TouchScreen_ADS7843.c
  group Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_exti.c
  group BaseDriver
    ../BaseDrive/: SystemClock.c Nvic.c Systick.c
  group ExternalDrive/lcd
    ../ExternalDrive/Lcd/: lcd.c bmp.c
  group Readme
    ../: readme.txt
